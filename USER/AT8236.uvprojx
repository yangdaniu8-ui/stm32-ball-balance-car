# Keil uVision project AT8236.uvprojx, settings and files
target BallCar_FreeRTOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWER\MOTO;..\HAREWER\PWM;..\HAREWER\GPIO;..\HAREWER\ADC;..\HAREWER\ENCODER;..\HAREWER\SERVO;..\HAREWER\ULTRASONIC;..\HAREWER\LINEWALKING;..\HAREWER\IRAVOID;..\HAREWER\bsp;..\HAREWER\PS2_Control;..\HAREWER\THREE_LINEWALKING;..\HAREWER\OLED;..\HAREWER\KEY;..\HAREWER\BALANCE;.\APP;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\ball_car.sct
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HAREWER
    ../HAREWER/bsp/: bsp.c
    ../HAREWER/MOTO/: moto.c
    ../HAREWER/LINEWALKING/: linewalking.c
    ../HAREWER/OLED/: oled.c
    ../HAREWER/KEY/: key.c
    ../HAREWER/BALANCE/: balance.c
  group APP
    ./APP/: app_tasks.c app_core.c control_math.c vision_protocol.c
  group FreeRTOS V11.1.0
    ../Middlewares/FreeRTOS/: tasks.c queue.c list.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
